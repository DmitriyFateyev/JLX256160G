#ifndef FONT_IND_12_H
#define FONT_IND_12_H

#include <stdint.h>

/*
 * Industrial Font for ST75256 — 11px tall in 7x16 cell
 * Format: font_bmp compatible (7 bytes page0 + 7 bytes page1)
 * Column-major, MSB = top row of page (same as font_bmp)
 * 
 * Index: 0-9='0'-'9', 10='.', 11='H', 12='z', 13='V', 14='A',
 *        15=' ', 16='W', 17='k', 18='-', 19=':', 20='%'
 */

#define FONT_IND_COUNT 21

static const uint8_t font_ind[FONT_IND_COUNT][14] = {
    {0x7F, 0xFF, 0x84, 0x88, 0x90, 0xFF, 0x7F, 0xC0, 0xE0, 0x20, 0x20, 0x20, 0xE0, 0xC0},  // '0'
    {0x20, 0x60, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x20, 0xE0, 0xE0, 0x20, 0x20, 0x20},  // '1'
    {0x41, 0xC3, 0x86, 0x8C, 0x98, 0xF0, 0x60, 0xE0, 0xE0, 0x20, 0x20, 0x20, 0x60, 0x60},  // '2'
    {0x40, 0xC0, 0x88, 0x88, 0x88, 0xFF, 0x77, 0x40, 0x60, 0x20, 0x20, 0x20, 0xE0, 0xC0},  // '3'
    {0x0E, 0x1E, 0x32, 0x62, 0xFF, 0xFF, 0x02, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00},  // '4'
    {0xF0, 0xF0, 0x90, 0x90, 0x90, 0x9F, 0x8F, 0x40, 0x60, 0x20, 0x20, 0x20, 0xE0, 0xC0},  // '5'
    {0x7F, 0xFF, 0x90, 0x90, 0x90, 0xDF, 0x4F, 0xC0, 0xE0, 0x20, 0x20, 0x20, 0xE0, 0xC0},  // '6'
    {0xC0, 0xC0, 0x83, 0x8F, 0x9C, 0xF0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00},  // '7'
    {0x77, 0xFF, 0x88, 0x88, 0x88, 0xFF, 0x77, 0xC0, 0xE0, 0x20, 0x20, 0x20, 0xE0, 0xC0},  // '8'
    {0x78, 0xFC, 0x84, 0x84, 0x84, 0xFF, 0x7F, 0x40, 0x60, 0x20, 0x20, 0x20, 0xE0, 0xC0},  // '9'
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x00},  // '.'
    {0xFF, 0xFF, 0x08, 0x08, 0x08, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xE0},  // 'H'
    {0x10, 0x10, 0x11, 0x13, 0x16, 0x1C, 0x18, 0x60, 0xE0, 0xA0, 0x20, 0x20, 0x20, 0x20},  // 'z'
    {0xF0, 0xFE, 0x0F, 0x01, 0x0F, 0xFE, 0xF0, 0x00, 0x00, 0x80, 0xE0, 0x80, 0x00, 0x00},  // 'V'
    {0x07, 0x1F, 0x79, 0xE1, 0x79, 0x1F, 0x07, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xE0},  // 'A'
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},  // ' '
    {0xFE, 0xFF, 0x01, 0x1F, 0x01, 0xFF, 0xFE, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xE0, 0x00},  // 'W'
    {0x3F, 0x3F, 0x06, 0x0F, 0x19, 0x10, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x20},  // 'k'
    {0x04, 0x04, 0x04, 0x04, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},  // '-'
    {0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x00},  // ':'
    {0xC0, 0xC3, 0x0F, 0x3C, 0xF0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00},  // '%'
};

static const uint8_t font_ind_width[FONT_IND_COUNT] = {
    7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 4, 7, 7, 7, 7, 4, 7, 7, 5, 4, 7
};

static inline uint8_t font_ind_index(char c) {
    if (c >= '0' && c <= '9') return c - '0';
    switch (c) {
        case '.': return 10;
        case 'H': return 11;
        case 'z': return 12;
        case 'V': return 13;
        case 'A': return 14;
        case ' ': return 15;
        case 'W': return 16;
        case 'k': return 17;
        case '-': return 18;
        case ':': return 19;
        case '%': return 20;
        default:  return 15;
    }
}

/*
 * Draw one character into framebuffer.
 * Uses EXACTLY the same method as st75256_draw_char_ru.
 * Returns pixel advance (width + 1px gap).
 */
static inline uint8_t draw_ind_char(uint8_t *fb, int x, int page, uint8_t idx) {
    if (idx >= FONT_IND_COUNT) idx = 15;
    const uint8_t *g = font_ind[idx];
    uint8_t w = font_ind_width[idx];

    /* For narrow glyphs (., :, space), offset into the 7-col data */
    uint8_t off = (w < 7) ? (7 - w) / 2 : 0;

    for (int col = 0; col < w; col++) {
        if (x + col >= 256) break;
        fb[page * 256 + x + col]       |= g[off + col];
        fb[(page + 1) * 256 + x + col] |= g[7 + off + col];
    }
    return w + 1;
}

/* Draw null-terminated ASCII string. Returns total pixel width. */
static inline uint16_t draw_ind_string(uint8_t *fb, int x, int page, const char *str) {
    int cx = x;
    while (*str) {
        uint8_t idx = font_ind_index(*str);
        cx += draw_ind_char(fb, cx, page, idx);
        str++;
    }
    return cx - x;
}

#endif /* FONT_IND_12_H */
