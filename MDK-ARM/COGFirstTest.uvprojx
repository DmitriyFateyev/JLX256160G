# Keil uVision project COGFirstTest.uvprojx, settings and files
target COGFirstTest (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: COGFirstTest +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,ARM_MATH_CM4
  c misc: --diag_suppress 188,223,546,177,111,1035
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c stm32f4xx_it.c stm32f4xx_hal_msp.c lv_example_1.c
    ./: old_code.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group LCD
    ../Core/Src/: st75256.c lv_port_disp.c ui_font_terminus_14.c ui_font_terminus_12.c ui_font_terminus_13.c
  group lvgl
    ../Core/Src/lvgl/: lv_version.h lvgl.h lvgl_private.h
    ../Core/Src/lvgl/src/: lv_api_map_v8.h lv_api_map_v9_0.h lv_api_map_v9_1.h lv_api_map_v9_2.h lv_api_map_v9_3.h lv_api_map_v9_4.h lv_conf_internal.h lv_conf_kconfig.h lv_init.c lv_init.h
    ../Core/Src/lvgl/src/core/: lv_global.h lv_group.c lv_group.h lv_group_private.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_class_private.h lv_obj_draw.c lv_obj_draw.h lv_obj_draw_private.h lv_obj_event.c lv_obj_event.h lv_obj_event_private.h lv_obj_id_builtin.c lv_obj_pos.c lv_obj_pos.h lv_obj_private.h lv_obj_property.c lv_obj_property.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_scroll_private.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_style_private.h lv_obj_tree.c lv_obj_tree.h lv_observer.c lv_observer.h lv_observer_private.h lv_refr.c lv_refr.h lv_refr_private.h
    ../Core/Src/lvgl/src/display/: lv_display.c lv_display.h lv_display_private.h
    ../Core/Src/lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_3d.c lv_draw_3d.h lv_draw_arc.c lv_draw_arc.h lv_draw_blur.c lv_draw_blur.h lv_draw_buf.c lv_draw_buf.h lv_draw_buf_private.h lv_draw_image.c lv_draw_image.h lv_draw_image_private.h lv_draw_label.c lv_draw_label.h lv_draw_label_private.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_private.h lv_draw_rect.c lv_draw_rect.h lv_draw_rect_private.h lv_draw_triangle.c lv_draw_triangle.h lv_draw_triangle_private.h lv_draw_vector.c lv_draw_vector.h lv_draw_vector_private.h lv_image_decoder.c lv_image_decoder.h lv_image_decoder_private.h lv_image_dsc.h
    ../Core/Src/lvgl/src/drivers/: lv_drivers.h
    ../Core/Src/lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_symbol_def.h
    ../Core/Src/lvgl/src/indev/: lv_gridnav.c lv_gridnav.h lv_indev.c lv_indev.h lv_indev_gesture.c lv_indev_gesture.h lv_indev_gesture_private.h lv_indev_private.h lv_indev_scroll.c lv_indev_scroll.h
    ../Core/Src/lvgl/src/layouts/: lv_layout.c lv_layout.h lv_layout_private.h
    ../Core/Src/lvgl/src/layouts/flex/: lv_flex.c lv_flex.h
    ../Core/Src/lvgl/src/layouts/grid/: lv_grid.c lv_grid.h
    ../Core/Src/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_private.h lv_anim_timeline.c lv_anim_timeline.h lv_anim_timeline_private.h lv_area.c lv_area.h lv_area_private.h lv_array.c lv_array.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_bidi_private.h lv_circle_buf.c lv_circle_buf.h lv_color.c lv_color.h lv_color_op.c lv_color_op.h lv_color_op_private.h lv_event.c lv_event.h lv_event_private.h lv_ext_data.h lv_fs.c lv_fs.h lv_fs_private.h lv_grad.c lv_grad.h lv_iter.c lv_iter.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_matrix.c lv_matrix.h lv_palette.c lv_palette.h lv_pending.c lv_pending.h lv_profiler.h lv_profiler_builtin.c lv_profiler_builtin.h lv_profiler_builtin_posix.c lv_profiler_builtin_private.h lv_rb.c lv_rb.h lv_rb_private.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_style_private.h lv_templ.c lv_templ.h lv_text.c lv_text.h lv_text_ap.c lv_text_ap.h lv_text_private.h lv_timer.c lv_timer.h lv_timer_private.h lv_tree.c lv_tree.h lv_types.h lv_utils.c lv_utils.h
    ../Core/Src/lvgl/src/stdlib/: lv_mem.c lv_mem.h lv_mem_private.h lv_sprintf.h lv_string.h
    ../Core/Src/lvgl/src/stdlib/builtin/: LICENSE_SPRINTF.txt LICENSE_TLSF.txt lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c lv_tlsf.h lv_tlsf_private.h
    ../Core/Src/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Core/Src/lvgl/src/themes/: lv_theme.c lv_theme.h lv_theme_private.h
    ../Core/Src/lvgl/src/themes/simple/: lv_theme_simple.c lv_theme_simple.h
    ../Core/Src/lvgl/src/themes/mono/: lv_theme_mono.c lv_theme_mono.h
    ../Core/Src/lvgl/src/themes/default/: lv_theme_default.c lv_theme_default.h
    ../Core/Src/lvgl/src/tick/: lv_tick.c lv_tick.h lv_tick_private.h
    ../Core/Src/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c lv_buttonmatrix.h lv_buttonmatrix_private.h
    ../Core/Src/lvgl/src/widgets/arc/: lv_arc.c lv_arc.h lv_arc_private.h
    ../Core/Src/lvgl/src/widgets/arclabel/: lv_arclabel.c lv_arclabel.h lv_arclabel_private.h
    ../Core/Src/lvgl/src/widgets/bar/: lv_bar.c lv_bar.h lv_bar_private.h
    ../Core/Src/lvgl/src/widgets/button/: lv_button.c lv_button.h lv_button_private.h
    ../Core/Src/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_chinese.c lv_calendar_chinese.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h lv_calendar_private.h
    ../Core/Src/lvgl/src/widgets/canvas/: lv_canvas.c lv_canvas.h lv_canvas_private.h
    ../Core/Src/lvgl/src/widgets/chart/: lv_chart.c lv_chart.h lv_chart_private.h
    ../Core/Src/lvgl/src/widgets/checkbox/: lv_checkbox.c lv_checkbox.h lv_checkbox_private.h
    ../Core/Src/lvgl/src/widgets/dropdown/: lv_dropdown.c lv_dropdown.h lv_dropdown_private.h
    ../Core/Src/lvgl/src/widgets/image/: lv_image.c lv_image.h lv_image_private.h
    ../Core/Src/lvgl/src/widgets/imagebutton/: lv_imagebutton.c lv_imagebutton.h lv_imagebutton_private.h
    ../Core/Src/lvgl/src/widgets/ime/: lv_ime_pinyin.c lv_ime_pinyin.h lv_ime_pinyin_private.h
    ../Core/Src/lvgl/src/widgets/keyboard/: lv_keyboard.c lv_keyboard.h lv_keyboard_private.h
    ../Core/Src/lvgl/src/widgets/label/: lv_label.c lv_label.h lv_label_private.h
    ../Core/Src/lvgl/src/widgets/led/: lv_led.c lv_led.h lv_led_private.h
    ../Core/Src/lvgl/src/widgets/line/: lv_line.c lv_line.h lv_line_private.h
    ../Core/Src/lvgl/src/widgets/list/: lv_list.c lv_list.h
    ../Core/Src/lvgl/src/widgets/lottie/: lv_lottie.c lv_lottie.h lv_lottie_private.h
    ../Core/Src/lvgl/src/widgets/menu/: lv_menu.c lv_menu.h lv_menu_private.h
    ../Core/Src/lvgl/src/widgets/msgbox/: lv_msgbox.c lv_msgbox.h lv_msgbox_private.h
    ../Core/Src/lvgl/src/widgets/objx_templ/: lv_objx_templ.c lv_objx_templ.h
    ../Core/Src/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_obj_property_names.h lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_style_properties.h lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../Core/Src/lvgl/src/widgets/roller/: lv_roller.c lv_roller.h lv_roller_private.h
    ../Core/Src/lvgl/src/widgets/scale/: lv_scale.c lv_scale.h lv_scale_private.h
    ../Core/Src/lvgl/src/widgets/slider/: lv_slider.c lv_slider.h lv_slider_private.h
    ../Core/Src/lvgl/src/widgets/span/: lv_span.c lv_span.h lv_span_private.h
    ../Core/Src/lvgl/src/widgets/spinbox/: lv_spinbox.c lv_spinbox.h lv_spinbox_private.h
    ../Core/Src/lvgl/src/widgets/spinner/: lv_spinner.c lv_spinner.h lv_spinner_private.h
    ../Core/Src/lvgl/src/widgets/switch/: lv_switch.c lv_switch.h lv_switch_private.h
    ../Core/Src/lvgl/src/widgets/table/: lv_table.c lv_table.h lv_table_private.h
    ../Core/Src/lvgl/src/widgets/tabview/: lv_tabview.c lv_tabview.h lv_tabview_private.h
    ../Core/Src/lvgl/src/widgets/textarea/: lv_textarea.c lv_textarea.h lv_textarea_private.h
    ../Core/Src/lvgl/src/widgets/win/: lv_win.c lv_win.h lv_win_private.h
    ../Core/Src/lvgl/src/widgets/3dtexture/: lv_3dtexture.c lv_3dtexture.h lv_3dtexture_private.h
    ../Core/Src/lvgl/src/widgets/animimage/: lv_animimage.c lv_animimage.h lv_animimage_private.h
    ../Core/Src/lvgl/src/widgets/gif/: lv_gif.c lv_gif.h
    ../Core/Src/lvgl/src/widgets/tileview/: lv_tileview.c lv_tileview.h lv_tileview_private.h
    ../Core/Src/lvgl/src/font/binfont_loader/: lv_binfont_loader.c lv_binfont_loader.h
    ../Core/Src/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_fmt_txt_private.h
    ../Core/Src/lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager.h lv_font_manager_recycle.c lv_font_manager_recycle.h
    ../Core/Src/lvgl/src/font/imgfont/: lv_imgfont.c lv_imgfont.h
    ../Core/Src/lvgl/src/misc/cache/: lv_cache.c lv_cache.h lv_cache_entry.c lv_cache_entry.h lv_cache_entry_private.h lv_cache_private.h
    ../Core/Src/lvgl/src/misc/cache/class/: lv_cache_class.h lv_cache_lru_ll.c lv_cache_lru_ll.h lv_cache_lru_rb.c lv_cache_lru_rb.h lv_cache_sc_da.c lv_cache_sc_da.h
    ../Core/Src/lvgl/src/misc/cache/instance/: lv_cache_instance.h lv_image_cache.c lv_image_cache.h lv_image_header_cache.c lv_image_header_cache.h
    ../Core/Src/lvgl/src/debugging/monkey/: lv_monkey.c lv_monkey.h lv_monkey_private.h
    ../Core/Src/lvgl/src/debugging/sysmon/: lv_sysmon.c lv_sysmon.h lv_sysmon_private.h
    ../Core/Src/lvgl/src/debugging/test/: lv_test.h lv_test_display.c lv_test_display.h lv_test_fs.c lv_test_fs.h lv_test_helpers.c lv_test_helpers.h lv_test_indev.c lv_test_indev.h lv_test_indev_gesture.c lv_test_indev_gesture.h lv_test_private.h lv_test_screenshot_compare.c lv_test_screenshot_compare.h
    ../Core/Src/lvgl/src/debugging/vg_lite_tvg/: vg_lite.h vg_lite_matrix.c vg_lite_tvg.cpp
    ../Core/Src/lvgl/src/draw/convert/: lv_draw_buf_convert.c lv_draw_buf_convert.h
    ../Core/Src/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d.h lv_draw_dma2d_fill.c lv_draw_dma2d_img.c lv_draw_dma2d_private.h
    ../Core/Src/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_grad.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask.h lv_draw_sw_mask_private.h lv_draw_sw_mask_rect.c lv_draw_sw_private.h lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_utils.h lv_draw_sw_vector.c
    ../Core/Src/lvgl/src/draw/sw/arm2d/: lv_draw_sw_arm2d.h lv_draw_sw_helium.h
    ../Core/Src/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_blend_private.h lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_a8.h lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_al88.h lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888.h lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_argb8888_premultiplied.h lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_i1.h lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_l8.h lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565.h lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb565_swapped.h lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend_to_rgb888.h
    ../Core/Src/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite.h lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_type.h lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_bitmap_font_cache.h lv_vg_lite_decoder.c lv_vg_lite_decoder.h lv_vg_lite_grad.c lv_vg_lite_grad.h lv_vg_lite_math.c lv_vg_lite_math.h lv_vg_lite_path.c lv_vg_lite_path.h lv_vg_lite_pending.c lv_vg_lite_pending.h lv_vg_lite_stroke.c lv_vg_lite_stroke.h lv_vg_lite_utils.c lv_vg_lite_utils.h
    ../Core/Src/lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c lv_draw_eve_display.h lv_draw_eve_display_defines.h
    ../Core/Src/lvgl/src/drivers/sdl/: lv_sdl_egl.c lv_sdl_keyboard.c lv_sdl_keyboard.h lv_sdl_mouse.c lv_sdl_mouse.h lv_sdl_mousewheel.c lv_sdl_mousewheel.h lv_sdl_private.h lv_sdl_sw.c lv_sdl_texture.c lv_sdl_window.c lv_sdl_window.h
    ../Core/Src/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland.h lv_wayland_private.h lv_wl_backend_private.h lv_wl_egl_backend.c lv_wl_g2d_backend.c lv_wl_keyboard.c lv_wl_keyboard.h lv_wl_pointer.c lv_wl_pointer.h lv_wl_pointer_axis.h lv_wl_seat.c lv_wl_shm_backend.c lv_wl_touch.c lv_wl_touch.h lv_wl_window.c lv_wl_window.h lv_wl_xdg_shell.c
    ../Core/Src/lvgl/src/osal/: lv_cmsis_rtos2.c lv_cmsis_rtos2.h lv_freertos.c lv_freertos.h lv_linux.c lv_linux.h lv_mqx.c lv_mqx.h lv_os.c lv_os.h lv_os_none.c lv_os_none.h lv_os_private.h lv_pthread.c lv_pthread.h lv_rtthread.c lv_rtthread.h lv_sdl2.c lv_sdl2.h lv_windows.c lv_windows.h
    ../Core/Src/lvgl/src/others/file_explorer/: lv_file_explorer.c lv_file_explorer.h lv_file_explorer_private.h
    ../Core/Src/lvgl/src/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c lv_fragment_private.h
    ../Core/Src/lvgl/src/others/translation/: lv_translation.c lv_translation.h lv_translation_private.h
    ../Core/Src/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c lv_bin_decoder.h
    ../Core/Src/lvgl/src/libs/bmp/: lv_bmp.c lv_bmp.h
    ../Core/Src/lvgl/src/libs/freetype/: freetype-LICENSE.txt ftmodule.h ftoption.h LiberationSans-LICENSE.txt lv_freetype.c lv_freetype.h lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_freetype_private.h lv_ftsystem.c
    ../Core/Src/: lv_conf.h
software components: CMSIS:CORE 6.2.0, Compiler:I/O:STDOUT 1.2.0
